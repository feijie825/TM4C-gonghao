# Keil uVision project CBOOT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123BH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: CBOOT
  BeforeMake: armcc --device DLM -I . -E -o ..\User_h\bl_config.inc ..\User_C\bl_config.c
  AfterMake: fromelf --bin --output ..\Project_MDK\output\CBoot.bin ..\Project_MDK\CBOOT.axf
  c flags: Optim=2
  c define: rvmdk PART_TM4C123GH6PGE
  c include: ..\..\inc;..\User_h;..\..\CAN_bootloader;..\Project_MDK
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\CBOOT.sct
  link misc: --entry Reset_Handler
  group Library
    ../User_C/: bl_can.c bl_check.c bl_flash.c bl_packet.c DISP.C
    ../../driverlib/: gpio.c sysctl.c systick.c interrupt.c cpu.c
  group Startup
    ../StartUp/: bl_startup_rvmdk.S
  group Readme
    ../Readme/: 说明.txt

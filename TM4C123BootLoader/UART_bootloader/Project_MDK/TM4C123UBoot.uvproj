# Keil uVision project TM4C123UBoot.uvproj, settings and files
target TM4C123UBoot (ARM-ADS)
  device: TM4C123BH6PGE Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: UBoot
  BeforeMake: armcc --device DLM -I . -E -o ..\User_h\bl_config.inc ..\User_C\bl_config.c
  AfterMake: fromelf --bin --output ..\Project_MDK\output\UBoot.bin ..\Project_MDK\UBoot.axf
  c flags: Optim=2 OneElfS=1
  c define: PART_TM4C123BH6PGE
  c misc: --c99
  c include: ..\..\inc;..\User_h;..\..\UART_bootloader;..\Project_MDK
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\bl_link.sct
  link misc: --entry Reset_Handler
  group Library
    ../User_C/: bl_autobaud.c bl_can.c bl_check.c bl_crc32.c bl_decrypt.c bl_emac.c bl_flash.c bl_main.c bl_packet.c bl_i2c.c bl_ssi.c bl_uart.c bl_usb.c bl_usbfuncs.c DISP.C
    ../../driverlib/: gpio.c sysctl.c interrupt.c systick.c cpu.c
  group Startup
    ../StartUp/: bl_startup_rvmdk.S
  group Readme
    ../Readme/: 说明.txt

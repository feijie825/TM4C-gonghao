# Keil uVision project bootloader.uvproj, settings and files
target bootloader (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: bootloader +hex
  BeforeMake: C:\Keil\ARM\ARMCC\bin\armcc.exe --device DLM -I . -E -o bl_config.inc bl_config.c
  AfterMake: fromelf.exe --bin -o .\output\bootloader.bin .\rvmdk\bootloader.axf
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\bl_link.sct
  link misc: --entry Reset_Handler
  group 源程序
    ./: bl_can.c bl_check.c bl_flash.c bl_packet.c
  group 启动程序
    ./: bl_startup_rvmdk.S
  group 说明
    ./: 说明.txt

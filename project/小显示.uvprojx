# Keil uVision project 小显示.uvprojx, settings and files
target 小显示 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123BH6PGE Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: 小显示 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: PART_TM4C123BH6PGE
  c include: ..\..\TM4C123BH6PGE-V1.0.0-TEST;..\inc;..\user_h
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group 库文件
    ../driverlib/: ssi.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c watchdog.c can.c cpu.c eeprom.c flash.c fpu.c gpio.c interrupt.c mpu.c adc.c
  group 启动程序
    ../user_c/: startup_rvmdk.S
  group 应用程序
    ../user_c/: BitVari.C CAN_API.C CLK_ERR.C Disp.C Init.C Interrupt_API.C main.c UART_API.C vari.c ENG_ERR.C Usr_Lib.c
  group 说明
    ../readme/: 说明.txt
